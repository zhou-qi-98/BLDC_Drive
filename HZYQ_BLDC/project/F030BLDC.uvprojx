# Keil uVision project F030BLDC.uvprojx, settings and files
target F030BLDC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: airute_Thermostat +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\CMSIS;..\Source\FWLib\inc;..\Source\User_Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Start_Up
    ../Source/Start_Up/: startup_stm32f030.s
  group CMSIS
    ../Source/CMSIS/: arm_common_tables.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h stm32f0xx.h stm32f0xx_conf.h stm32f0xx_it.h system_stm32f0xx.h
  group FWlib
    ../Source/FWLib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User_Inc
    ../Source/User_Inc/: adc.h control.h display.h eeprom.h global.h gpio.h iwdg.h key.h lcd.h myiic.h queue.h rf_slave.h rtc.h sht20.h spi.h sx1276.h sx1276_ApiLyr.h sx1276_PhyLyr.h sx1276-Hal.h sx1276-LoRa.h sx1276-LoRaMisc.h timer.h typedef.h ui.h usart.h var.h
  group APP
    ../Source/APP/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group MyDrivers
    ../Source/MyDrivers/: adc.c gpio.c iwdg.c usart.c motor.c timer.c bsp.c control.c spi.c protect.c
